# Autodesk Inventor assembly: SP060112-1 DOOR ASSY
## iProperties
Created: 2012-06
Part Number: SP060112-1 DOOR ASSY
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
