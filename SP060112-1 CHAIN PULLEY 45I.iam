# Autodesk Inventor assembly: SP060112-1
## iProperties
Created: 2012-06
Part Number: SP060112-1
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
